# Keil uVision project 1.ADC_Data_Acquisition.uvprojx, settings and files
target 1.ADC_Data_Acquisition (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  output: 1.ADC_Data_Acquisition
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .;src;lib\cmsis;hal\STM32F10x_StdPeriph_Driver;hal\STM32F10x_StdPeriph_Driver\inc;hal\STM32F10x_StdPeriph_Driver\src
  asm define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  memory RVCT1: RAM 0x08000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x2800
  scatter file: f:\Ubuntu\Cpp\STM32F1\Module Practise\11.ADC data acquisttion\1.ADC_Data_Acquisition_Independent\stm32f1x_64KB_flash.ld
  group SRC
    src/: main.c startup_stm32f10x_md.s stm32f10x_it.c
  group SRC/MODULE/SRC
    src/Module/src/: ADC.c MyDelay.c OLED.c
  group HAL/STM32F10X_STDPERIPH_DRIVER
    hal/STM32F10x_StdPeriph_Driver/: system_stm32f10x.c
  group HAL/STM32F10X_STDPERIPH_DRIVER/SRC
    hal/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
